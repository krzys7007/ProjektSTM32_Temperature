/*
 * Display_Animations.c
 *
 *  Created on: Jan 24, 2024
 *      Author: krzys
 */

#include "Display_Animations.h"
#include "ssd1306.h"

const unsigned char termometr [] = {
		0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xe0, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
			0x00, 0x00, 0x7f, 0xff, 0x00, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x00, 0x10, 0xfc, 0x00, 0x00,
			0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x04, 0x26, 0x00, 0x00, 0x00, 0x23, 0xfe, 0x00, 0x00,
			0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x00, 0x26, 0x0c, 0x00, 0x00,
			0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x00, 0x05, 0xa0, 0x00, 0x00, 0x00, 0x7c, 0x58, 0x00, 0x00,
			0x00, 0x07, 0x77, 0xd1, 0x70, 0x00, 0x00, 0x05, 0xa6, 0x00, 0x00, 0x00, 0x4c, 0x5c, 0x00, 0x00,
			0x00, 0x09, 0x41, 0x1b, 0x48, 0x00, 0x00, 0x05, 0xa0, 0x00, 0x00, 0x00, 0x4e, 0x02, 0x00, 0x00,
			0x00, 0x01, 0x71, 0x15, 0x40, 0x00, 0x00, 0x05, 0xa0, 0x00, 0x00, 0x00, 0x44, 0x82, 0x00, 0x00,
			0x00, 0x07, 0x11, 0x11, 0x70, 0x00, 0x00, 0x05, 0xa6, 0x00, 0x00, 0x00, 0x21, 0xe7, 0x00, 0x00,
			0x00, 0x09, 0x71, 0x11, 0x48, 0x00, 0x00, 0x05, 0xa0, 0x00, 0x00, 0x00, 0x18, 0x7c, 0x00, 0x00,
			0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x00, 0x05, 0xa0, 0x00, 0x00, 0x00, 0x3c, 0x10, 0x00, 0x00,
			0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x00, 0x05, 0xa6, 0x00, 0x00, 0x00, 0x47, 0xe0, 0x00, 0x00,
			0x00, 0x07, 0x07, 0x70, 0x70, 0x00, 0x00, 0x05, 0xa0, 0x00, 0x00, 0x00, 0x47, 0x14, 0x00, 0x00,
			0x00, 0x09, 0x01, 0x10, 0x48, 0x00, 0x00, 0x05, 0xa0, 0x00, 0x00, 0x00, 0x88, 0x8a, 0x00, 0x00,
			0x00, 0x01, 0x07, 0x70, 0x40, 0x00, 0x00, 0x05, 0xa6, 0x00, 0x00, 0x00, 0x90, 0x4a, 0x00, 0x00,
			0x00, 0x07, 0x01, 0x40, 0x70, 0x00, 0x00, 0x05, 0xa0, 0x00, 0x00, 0x00, 0x90, 0x4c, 0x00, 0x00,
			0x00, 0x09, 0x07, 0x70, 0x48, 0x00, 0x00, 0x05, 0xa0, 0x00, 0x00, 0x00, 0xc8, 0xb4, 0x00, 0x00,
			0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x00, 0x09, 0x90, 0x00, 0x00, 0x00, 0x47, 0x34, 0x00, 0x00,
			0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x0b, 0xd0, 0x00, 0x00, 0x00, 0x7f, 0xfc, 0x00, 0x00,
			0x00, 0x00, 0x7f, 0xff, 0x00, 0x00, 0x00, 0x0b, 0xd0, 0x00, 0x00, 0x00, 0x3f, 0xfe, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x09, 0x90, 0x00, 0x00, 0x00, 0x5f, 0xf9, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x00, 0x5f, 0x71, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xc0, 0x00, 0x00, 0x00, 0x4e, 0x22, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x21, 0x24, 0x00, 0x00,
			0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1f, 0x18, 0x00, 0x00
	};
void Graf(){
	char myText[] = "C";
	char myText2[] = "t";
	ssd1306_Fill(Black);
	ssd1306_Line(2, 61, 121, 61, White);
	ssd1306_Line(2, 61, 2, 3, White);
	ssd1306_DrawCircle(5, 1, 1, White);
	ssd1306_DrawPixel(1, 4, White);
	ssd1306_DrawPixel(0, 5, White);
	ssd1306_DrawPixel(3, 4, White);
	ssd1306_DrawPixel(4, 5, White);
	ssd1306_DrawPixel(120, 60, White);
	ssd1306_DrawPixel(119, 59, White);
	ssd1306_DrawPixel(120, 62, White);
	ssd1306_DrawPixel(119, 63, White);
	ssd1306_SetCursor(8, 0);
	ssd1306_WriteString(myText, Font_6x8, White);
	ssd1306_SetCursor(122, 56);
	ssd1306_WriteString(myText2, Font_6x8, White);
};

void DottedLine(int y1){
	for (int i = 0; i < 19; i++){
		ssd1306_Line((i*6) + 5, y1, (i*6) + 5 + 3, y1, White);
	}
}


void TempZadScreen(float Temp, float TempZad){
	char x[] = "12.12";
	snprintf(x, sizeof(x),"%f", Temp);
	char x1[] = "12.12";
	snprintf(x1, sizeof(x1),"%f", TempZad);
	char myText1[] = "Set Temp.";
	char myText[] = "Current Temp.";
	ssd1306_Fill(Black);
	ssd1306_SetCursor(10, 5);
	ssd1306_WriteString(myText, Font_6x8, White);
	ssd1306_SetCursor(95, 5);
	ssd1306_WriteString(x, Font_6x8, White);
	ssd1306_SetCursor(95, 20);
	ssd1306_WriteString(x1, Font_6x8, White);
	ssd1306_SetCursor(10, 20);
	ssd1306_WriteString(myText1, Font_6x8, White);
	ssd1306_DrawBitmap(0, 37, termometr, 128, 27, White);
};

void rysuj_wykres(int wykres[118]){
	for(int i = 0; i < 116; i++){
		ssd1306_DrawPixel(i + 3, wykres[i], White);
		int ilosc = abs(wykres[i] - wykres[i + 1] - 1);
		if (ilosc > 1){
			int y = wykres[i] - wykres[i + 1];
			if (y < 0){
				for (int j = 0; j < ilosc; j++){
					ssd1306_DrawPixel(i + 3, wykres[i] + j, White);
				}
			}else{
				for (int j = 0; j < ilosc; j++){
					ssd1306_DrawPixel(i + 3, wykres[i] - j, White);
				}
			}
		}
	}
	ssd1306_DrawPixel(119, wykres[117], White);
}


void ssd1306_TestDrawBitmap()
{
    ssd1306_Fill(White);
}
